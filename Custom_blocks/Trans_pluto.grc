<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lb_system</value></param>
<param><key>author</key><value>dieter</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Loop Back</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constel</value></param>
<param><key>const_points</key><value>digital.psk_2()[0]</value></param>
<param><key>type</key><value>bpsk</value></param>
<param><key>rot_sym</key><value>2</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_2()[1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>eb</value></param>
<param><key>value</key><value>0.22</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab0@1</value></param>
<param><key>label</key><value>Frequency Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-0.001</value></param>
<param><key>step</key><value>0.00002</value></param>
<param><key>stop</key><value>0.001</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>0.005</value></param>
<param><key>gui_hint</key><value>tab0@3</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.005</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nr_packet</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_size</value></param>
<param><key>value</key><value>56</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>tab0@2</value></param>
<param><key>label</key><value>Phase offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-2*3.14</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>2*3.14</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>[1,-1,1,-1,1,1,-1,-1,1,1,-1,1,1,1,-1,1,1,-1,1,-1,-1,1,-1,-1,1,1,1,-1,-1,-1,1,-1,1,1,1,1,-1,-1,1,-1,1,-1,-1,-1,1,1,-1,-1,-1,-1,1,-1,-1,-1,-1,-1,1,1,1,1,1,1,-1,-1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_dec</value></param>
<param><key>value</key><value>[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>rx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>11*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts*sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>time_offset</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>tab0@0</value></param>
<param><key>label</key><value>Timing Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.995</value></param>
<param><key>step</key><value>0.00001</value></param>
<param><key>stop</key><value>1.005</value></param>
<param><key>widget</key><value>slider</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>tx_rrc_taps</value></param>
<param><key>alpha</key><value>eb</value></param>
<param><key>gain</key><value>nfilts</value></param>
<param><key>ntaps</key><value>5*sps*nfilts</value></param>
<param><key>samp_rate</key><value>nfilts</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>Packet_Builder</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import pmt

class msg_block(gr.basic_block):
    def __init__(self,Packet_len = 60):
        gr.basic_block.__init__(
            self,
            name="Packet Generator",
            in_sig=None,
            out_sig=None)

        self.Packet_len = Packet_len
        self.message_port_register_in(pmt.intern('GEN'))
        self.message_port_register_out(pmt.intern('packet'))
        self.set_msg_handler(pmt.intern('GEN'), self.handle_msg)
        self.counter = 0

    def handle_msg(self, msg):
        self.counter +=1
        if self.counter&gt;255:
            self.counter = 0
            print "counter ressetted"
        data = np.random.randint(255, size=self.Packet_len, dtype=np.uint8)
        data = np.ones(self.Packet_len, dtype=np.uint8)*self.counter

        # preamble!
        #data[0:2] = [229,114]
        data_ba = bytearray(data)
        vector = pmt.init_u8vector(self.Packet_len, data_ba)# &lt;- byte array nodig!
        data = pmt.cons(pmt.PMT_NIL, vector )
        self.message_port_pub(pmt.intern('packet'), data)
</value></param>
<param><key>Packet_len</key><value>payload_size</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>Packet_Inserter</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import pmt


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, sample_rate = 32000,Packets_per_second = 1 ):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Packe Inserter',   # will show up in GRC
            in_sig=[],
            out_sig=[np.complex64]
        )
        # Set up msg port
        self.message_port_register_in(pmt.intern('in'))
        self.set_msg_handler(pmt.intern('in'), self.handle_pkt)

        # Set up variables
        self.sample_rate = sample_rate
        self.cnt = 0
        self.msg_queue = []
        self.pps = Packets_per_second #PPS = packets per second
        self.cnt_reset = int(sample_rate/Packets_per_second)
        self.chopped = False

        # Information for us
        self.pktcnt=0
        self.abs_counter = 0


    def handle_pkt(self,msg_pmt):
        """ Make PDU into message and save it in the queque"""
        # Collect metadata, convert to Python format:
        meta = pmt.to_python(pmt.car(msg_pmt))

        # Collect message, convert to Python format:
        msg = pmt.to_python(pmt.cdr(msg_pmt))
        self.pktcnt+=1
        print self.pktcnt
        self.msg_queue.append(msg)



    def work(self, input_items, output_items):
        """ Insert packet on regular scedule"""

        # clear output buffers
        nout0 = len(output_items[0])
        output_items[0][:] = 0

        # Update counter
        self.cnt -= nout0

        # Solve chopped packets
        if self.chopped:
            #print "chopped"
            # Does it fit
            if len(output_items[0]) &lt; len(self.msg_queue[0]):
                #print "if"
                # nope buffer too small; fill buffer completely
                output_items[0][:] = self.msg_queue[0][:len(output_items[0])]
                self.msg_queue[0] = self.msg_queue[0][len(output_items[0]):]
            else:
                #print "else"
                # Fits completely
                output_items[0][:len(self.msg_queue[0])] = self.msg_queue[0][:]
                self.msg_queue.pop(0)
                self.chopped = False

        # At least one packet should be put in this buffer
        while self.cnt&lt;0:
            #print "while"

            # check if message available
            if len(self.msg_queue) &gt; 0:
                #print "msg available"
                # check if fits completely in buffer
                if len(self.msg_queue[0]) + self.cnt &lt;0:
                    #print "if"
                    # put it in
                    output_items[0][self.cnt:self.cnt + len(self.msg_queue[0])] = self.msg_queue[0][:]

                    # Delete used message
                    self.msg_queue.pop(0)
                elif len(self.msg_queue[0]) + self.cnt ==0:
                    #print "elif"
                    # Past perfect
                    output_items[0][self.cnt:] = self.msg_queue[0][:]

                    # Delete used message
                    self.msg_queue.pop(0)
                else: # Packet must be chopped
                    #print "else"
                    # Fill with as many as possible
                    output_items[0][self.cnt:] = self.msg_queue[0][:-self.cnt]
                    # Save the rest for a rainy day
                    self.msg_queue[0] = self.msg_queue[0][-self.cnt:]
                    # Make sure you don' forget about it.
                    self.chopped = True

            self.cnt += self.cnt_reset

        return len(output_items[0])
</value></param>
<param><key>Packets_per_second</key><value>nr_packet</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>Transmit_packet</key>
<param><key>id</key><value>Transmit_packet_0</value></param>
<param><key>payload_size</key><value>payload_size</value></param>
<param><key>constel</key><value>constel</value></param>
<param><key>preamble</key><value>preamble</value></param>
<param><key>psf_taps</key><value>tx_rrc_taps</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("GEN")</value></param>
<param><key>period</key><value>1000/nr_packet</value></param>
</block>
<block>
<key>pluto_sink</key>
<param><key>id</key><value>pluto_sink_0</value></param>
<param><key>attenuation</key><value>0</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>cyclic</key><value>False</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>uri</key><value>usb:2.13.5</value></param>
<param><key>frequency</key><value>868.9e6</value></param>
<param><key>bandwidth</key><value>2e6</value></param>
<param><key>samplerate</key><value>4e6</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>20</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab0</value></param>
<param><key>label0</key><value>Time</value></param>
<param><key>label1</key><value>Freq.</value></param>
<param><key>label2</key><value>phase</value></param>
<param><key>label3</key><value>noise</value></param>
<param><key>num_tabs</key><value>4</value></param>
</block>
<connection><source_block_id>Packet_Builder</source_block_id><sink_block_id>Transmit_packet_0</sink_block_id><source_key>packet</source_key><sink_key>Pkt</sink_key></connection>
<connection><source_block_id>Packet_Inserter</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Transmit_packet_0</source_block_id><sink_block_id>Packet_Inserter</sink_block_id><source_key>modpkt</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>Packet_Builder</sink_block_id><source_key>strobe</source_key><sink_key>GEN</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>pluto_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
